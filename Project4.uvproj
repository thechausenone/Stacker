# Keil uVision project Project4.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: LPC1768 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10007FFF) IRAM2(0x2007C000-0x20083FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE("Cortex-M3")
  output: Project4
  c flags: Optim=1
  c define: __RTGT_UART
  library: MicroLIB
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x10000000 size 0x8000
  memory RVCT10: RAM 0x2007c000 size 0x8000
  group Startup Code
    ./: startup_LPC17xx.s
  group System Code
    ./Source Code/: RTX_config.c uart.c Retarget.c
    C:/Software/Keil/ARM/Startup/NXP/LPC17xx/: system_LPC17xx.c
  group Source Code
    ./Source Code/: Main.c lcd_display.c stat_display.c game_state.c
  group Peripherals
    ./Source Code/: led.c joystick.c potentiometer.c timer.c GLCD_Scroll.c GLCD_SPI_LPC1700.c
